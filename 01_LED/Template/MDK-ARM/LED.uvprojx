# Keil uVision project LED.uvprojx, settings and files
target Target 1 (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: GD32F303RC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.0.0
  cpu: IRAM(0x20000000,0x0C000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: LED
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: GD32F30X_XD
  c include: ..\..\Firmware\CMSIS\GD\GD32F30x\Include;..\..\Firmware\CMSIS;..\..\Firmware\GD32F30x_standard_peripheral\Include;..\..\Template
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  group Application
    ../: gd32f30x_it.c main.c systick.c
  group CMSIS
    ../../Firmware/CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
  group GD32F30x_Peripherals
    ../../Firmware/GD32F30x_standard_peripheral/Source/: gd32f30x_rcu.c gd32f30x_gpio.c
  group Startup
    ../../Firmware/CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_xd.s
  group Doc
    ../: readme.txt
